/*
 * Goomba.c
 *
 *  Created on: 28 cze 2026
 *      Author: tomasz
 */

#include "string.h"

#include "Goomba.h"


const uint16_t goomba_16x16_dma[256] = {
		0xffff, 0xffff, 0xffff, 0x0000, 0x0000, 0x0000, 0xd6fd, 0xd6fd, 0xd6fd, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xffff,
		0xffff, 0xffff, 0xffff, 0x0000, 0x0000, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xffff,
		0xffff, 0xffff, 0xffff, 0xffff, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0x0000, 0x0000, 0xffff, 0xffff,
		0xffff, 0xffff, 0xffff, 0xffff, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xffff, 0xffff, 0xffff, 0xffff,
		0xffff, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0xd6fd, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0xffff,
		0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9,
		0x04a9, 0x04a9, 0x04a9, 0x04a9, 0xd6fd, 0xd6fd, 0xd6fd, 0x04a9, 0x04a9, 0xd6fd, 0xd6fd, 0xd6fd, 0x04a9, 0x04a9, 0x04a9, 0x04a9,
		0x04a9, 0x04a9, 0x04a9, 0x04a9, 0xd6fd, 0x0000, 0xd6fd, 0x04a9, 0x04a9, 0xd6fd, 0x0000, 0xd6fd, 0x04a9, 0x04a9, 0x04a9, 0x04a9,
		0xffff, 0x04a9, 0x04a9, 0x04a9, 0xd6fd, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xd6fd, 0x04a9, 0x04a9, 0x04a9, 0xffff,
		0xffff, 0x04a9, 0x04a9, 0x04a9, 0xd6fd, 0x0000, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x0000, 0xd6fd, 0x04a9, 0x04a9, 0x04a9, 0xffff,
		0xffff, 0xffff, 0x04a9, 0x0000, 0x0000, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x0000, 0x0000, 0x04a9, 0xffff, 0xffff,
		0xffff, 0xffff, 0xffff, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0xffff, 0xffff, 0xffff,
		0xffff, 0xffff, 0xffff, 0xffff, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0xffff, 0xffff, 0xffff, 0xffff,
		0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff,
		0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0x04a9, 0x04a9, 0x04a9, 0x04a9, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff,
		0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff
	};

int Goomba_Init(Goomba_t* p)
{
	if (p == NULL)	{ return -1; }

	p->sprite.bitmap = goomba_16x16_dma;
	p->sprite.size.x = 16;
	p->sprite.size.y = 16;

	p->currMapPos.x = 100;
	p->currMapPos.y = 32;
	p->prevMapPos = p->currMapPos;

	return 0;
}

Sprite_t* Goomba_GetSprite(Goomba_t* p)
{
	if (p == NULL)	{ return NULL; }
	return &p->sprite;
}

int Goomba_GetDirtyRect(Goomba_t* p, Rect_t* dirtyRect)
{
	if (p == NULL || dirtyRect == NULL)	{ return -1; }

	Rect_t prevDirtyRect;
	prevDirtyRect.p1 = p->prevMapPos;
	prevDirtyRect.p2.x = p->prevMapPos.x + p->sprite.size.x;
	prevDirtyRect.p2.y = p->prevMapPos.y + p->sprite.size.y;

	Rect_t currDirtyRect;
	currDirtyRect.p1 = p->currMapPos;
	currDirtyRect.p2.x = p->currMapPos.x + p->sprite.size.x;
	currDirtyRect.p2.y = p->currMapPos.y + p->sprite.size.y;

	Rect_t commonDirtyRect;
	commonDirtyRect.p1.x = min(prevDirtyRect.p1.x, currDirtyRect.p1.x);
	commonDirtyRect.p1.y = min(prevDirtyRect.p1.y, currDirtyRect.p1.y);
	commonDirtyRect.p2.x = max(prevDirtyRect.p2.x, currDirtyRect.p2.x);
	commonDirtyRect.p2.y = max(prevDirtyRect.p2.y, currDirtyRect.p2.y);

	if (commonDirtyRect.p1.x <= commonDirtyRect.p2.x && commonDirtyRect.p1.y <= commonDirtyRect.p2.y)
	{
		*dirtyRect = commonDirtyRect;
	}
	else
	{
		return -5;
	}

	return 0;
}

int Goomba_GetMapPos(Goomba_t* p, Point_t* mapPos)
{
	if (p == NULL || mapPos == NULL)	{ return -1; }
	*mapPos = p->currMapPos;
	return 0;
}
